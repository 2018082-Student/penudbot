Commit message: lqr now working

File: urdfs/pendubot.urdf (robot description, URDF)
Before this commit: robot pendubot, 3 links, 2 joints
Joints:
- joint joint_1: axis 1 0 0 -> -1 0 0
- joint joint_2: axis 1 0 0 -> -1 0 0
